# Keil uVision project app.uvprojx, settings and files
target Release (5060020::V5.06 (build 20)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.7.2.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: app +hex
  AfterMake: fromelf --bin -o build\app.bin build\app.axf
  c flags: Optim=4 uC99=1
  c include: ..\..\..\include
  library: MicroLIB
  memory RVCT4: ROM 0x34000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\..\..\lib\juma_sdk.sct
  group Application
    ../: app.c
  group Library
    ../../../lib/: juma_sdk.lib
software components: CMSIS:CORE 3.40.0
