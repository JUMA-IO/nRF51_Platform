# Keil uVision project BoardConfig.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: BoardConfig
  AfterMake: fromelf -c  "#L" -o "$L@L.txt"
  AfterMake: fromelf --bin  "#L" -o "$L@L.bin"
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..\common\inc;..\..\Platform\Nordic;C:\Keil_v5\ARM\Pack\NordicSemiconductor\nRF_SoftDevice_S110\8.0.2\headers
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\common\config\BoardConfig.sct
  group common/inc
    ../common/inc/: boardconfig.h
  group common/src
    ../common/src/: boardconfig.c
software components: CMSIS:CORE 4.1.0
