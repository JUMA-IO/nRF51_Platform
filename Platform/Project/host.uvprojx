# Keil uVision project host.uvprojx, settings and files
target Host 256k (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: sdk_platform +hex
  c flags: Optim=1 uC99=1
  c define: __HEAP_SIZE=0 BLE_STACK_SUPPORT_REQD S120 BOARD_PCA10031 BSP_UART_SUPPORT NRF51 SOFTDEVICE_PRESENT
  c include: ..\Nordic;..\Project
  memory RVCT4: ROM 0x1d000 size 0x23000
  memory RVCT9: RAM 0x20002800 size 0x5800
  group User
    ./: main.c
  group Nordic
    ../Nordic/: ble_db_discovery.c device_manager_central.c
software components: CMSIS:CORE 3.20.0, Device:Startup 7.2.1, nRF_Drivers:nrf_delay 2.0.0, nRF_Drivers:nrf_error 2.0.0, nRF_Drivers:nrf_gpio 2.0.0, nRF_Drivers:nrf_gpiote 2.0.0, nRF_Drivers:nrf_soc 2.0.0, nRF_Drivers:pstorage 3.0.0, nRF_Libraries:app_error 3.0.0, nRF_Libraries:app_fifo 3.0.0, nRF_Libraries:app_trace 3.0.0, nRF_Libraries:app_util 2.0.0, nRF_Libraries:nrf_assert 3.0.0, nRF_SoftDevice:Internal:sd_common 1.1.2, nRF_SoftDevice:Internal:softdevice_in_use 1.1.2, nRF_SoftDevice:Internal:softdevice_present 1.1.2, nRF_SoftDevice:s120 2.0.0
