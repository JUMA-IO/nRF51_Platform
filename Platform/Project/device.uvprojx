# Keil uVision project device.uvprojx, settings and files
target Device (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: ble_device_platform +hex
  AfterMake: install_device.bat
  AfterMake: fromelf -c  "#L" -o "$L@L.bin.asm"
  c flags: Optim=1 uC99=1
  c define: UART_DEBUT_OUTPUT __HEAP_SIZE=0 BLE_STACK_SUPPORT_REQD S110  NRF51 SOFTDEVICE_PRESENT PSTORAGE_RAW_MODE_ENABLE
  c include: ..\Nordic;..\Project;..\Juma;..\..\Interface\Include;..\ThirdParty\glcd;..\..\BoardConfig\BoardConfig_UICR\common\inc
  asm define: __HEAP_SIZE=0
  memory RVCT4: ROM 0x1d000 size 0x23000
  memory RVCT9: RAM 0x20002800 size 0x5800
  scatter file: .\device.sct
  group Juma
    ../Juma/: device_main.c adc.c dispatch.c gpio.c juma_common.c juma_data_service.c light.c loader.c passive_buzzer.c sysmsg.c text.c drawing.c gfx.c timer.c ota.c serial.c data_storage.c flash_operation.c device_inf_request.c juma_sys_res_manage.c wdt.c device_statue.c device_option.c interface_spi.c interface_spi.h random.c
    ../../Interface/Source/: juma_sdk_sys_vectors.c
    ../Juma/infrared/: infrared_send_module.c infrared_send_pwm.c
  group Nordic
    ../Nordic/: ble_db_discovery.c ble_advdata.c app_uart_fifo_mod.c device_manager_peripheral.c simple_uart.c
software components: CMSIS:CORE 3.20.0, Device:Startup 7.1.0, nRF_Drivers:nrf_delay 2.0.0, nRF_Drivers:nrf_error 2.0.0, nRF_Drivers:nrf_gpio 2.0.0, nRF_Drivers:nrf_gpiote 2.0.0, nRF_Drivers:nrf_soc 2.0.0, nRF_Drivers:pstorage 2.0.0, nRF_Libraries:app_error 2.0.0, nRF_Libraries:app_fifo 2.0.0, nRF_Libraries:app_trace 2.0.0, nRF_Libraries:app_util 2.0.0, nRF_Libraries:nrf_assert 2.0.0, nRF_SoftDevice:Internal:sd_common 1.1.2, nRF_SoftDevice:Internal:softdevice_in_use 1.1.2, nRF_SoftDevice:Internal:softdevice_present 1.1.2, nRF_SoftDevice:s110 8.0.0
