# Keil uVision project BoardConfig_NOVA.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: BoardConfig +hex
  AfterMake: install.bat "#L" "$L@L"
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..\..\..\common\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\..\..\common\config\BoardConfig.sct
  group common/inc
    ../../../common/inc/: boardconfig.h
  group common/src
    ../user/src/: boardconfig.c
software components: CMSIS:CORE 4.1.0
